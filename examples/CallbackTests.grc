options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: CallbackTests
    output_language: python
    title: Testes Callback
  states: {}

blocks:
- name: const_to_add
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: p
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ITpp_BSC_Byte_0
  id: ITpp_BSC_Byte
  parameters:
    bits: '1'
    probability: p
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: const_to_add
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (15, 10, 0)
  states: {state: disabled}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (255, 0, 60)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '100'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: 3 * 8
    srate: samp_rate
    type: float
    ymax: '2'
  states: {}

connections:
- [ITpp_BSC_Byte_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', ITpp_BSC_Byte_0, '0']
- [blocks_vector_source_x_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_vector_source_x_1, '0', blocks_throttle_1, '0']

metadata:
  file_format: 1
