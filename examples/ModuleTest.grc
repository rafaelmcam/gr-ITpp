options:
  parameters:
    author: rcampello
    generate_options: qt_gui
    id: Test1
    output_language: python
    title: ModuleTest
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ITpp_BCH_Decoder_0
  id: ITpp_BCH_Decoder
  parameters:
    n: '15'
    t: '2'
  states: {}
- name: ITpp_BCH_Encoder_0
  id: ITpp_BCH_Encoder
  parameters:
    n: '15'
    t: '2'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (15, 123, 0)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha1: '1'
    alpha2: '0.5'
    label1: Original Bits
    label2: Decoded Bits
    marker1: '0'
    marker2: '0'
    name: '"Comparison"'
    nconnections: '2'
    size: 3 * 8 * 4
    srate: samp_rate
    stemplot: 'True'
    style1: '2'
    style2: '2'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: Encoded Bits
    marker1: '1'
    name: '"Encoded"'
    size: int(3 *7 * 8 * (15/7))
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}

connections:
- [ITpp_BCH_Decoder_0, '0', blocks_uchar_to_float_0, '0']
- [ITpp_BCH_Encoder_0, '0', ITpp_BCH_Decoder_0, '0']
- [ITpp_BCH_Encoder_0, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_throttle_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', ITpp_BCH_Encoder_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_uchar_to_float_0_1, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
